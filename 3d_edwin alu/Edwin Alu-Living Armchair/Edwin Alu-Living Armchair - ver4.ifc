Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Edwin Alu-Living Armchair - ver4.ifc
Time: 2025-11-26T15:30:51
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Edwin Alu-Living Armchair_0 - ObjectType: SketchupGroup
 | Edwin Alu-Living Armchair_1 - ObjectType: SketchupGroup
 | Edwin Alu-Living Armchair_2 - ObjectType: SketchupGroup
 | Edwin Alu-Living Armchair_3 - ObjectType: SketchupGroup
 | Edwin Alu-Living Armchair_4 - ObjectType: SketchupGroup
 | Edwin Alu-Living Armchair_5 - ObjectType: SketchupGroup
 | Edwin Alu-Living Armchair_6 - ObjectType: SketchupGroup
 | Edwin Alu-Living Armchair_7 - ObjectType: SketchupGroup
